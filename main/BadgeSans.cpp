#include "BadgeSans.h"

namespace
{
    static const uint8_t GlyphUnknown[5] =
        {0x02, 0x01, 0x59, 0x09, 0x06};

    static const uint8_t GlyphSpace[5] =
        {0x00, 0x00, 0x00, 0x00, 0x00};

    static const uint8_t Uppercase[26][5] =
    {
        {0x7E,0x11,0x11,0x11,0x7E}, // A
        {0x7F,0x49,0x49,0x49,0x36}, // B
        {0x3E,0x41,0x41,0x41,0x22}, // C
        {0x7F,0x41,0x41,0x22,0x1C}, // D
        {0x7F,0x49,0x49,0x49,0x41}, // E
        {0x7F,0x09,0x09,0x09,0x01}, // F
        {0x3E,0x41,0x49,0x49,0x7A}, // G
        {0x7F,0x08,0x08,0x08,0x7F}, // H
        {0x00,0x41,0x7F,0x41,0x00}, // I
        {0x20,0x40,0x41,0x3F,0x01}, // J
        {0x7F,0x08,0x14,0x22,0x41}, // K
        {0x7F,0x40,0x40,0x40,0x40}, // L
        {0x7F,0x02,0x0C,0x02,0x7F}, // M
        {0x7F,0x04,0x08,0x10,0x7F}, // N
        {0x3E,0x41,0x41,0x41,0x3E}, // O
        {0x7F,0x09,0x09,0x09,0x06}, // P
        {0x3E,0x41,0x51,0x21,0x5E}, // Q
        {0x7F,0x09,0x19,0x29,0x46}, // R
        {0x46,0x49,0x49,0x49,0x31}, // S
        {0x01,0x01,0x7F,0x01,0x01}, // T
        {0x3F,0x40,0x40,0x40,0x3F}, // U
        {0x1F,0x20,0x40,0x20,0x1F}, // V
        {0x3F,0x40,0x38,0x40,0x3F}, // W
        {0x63,0x14,0x08,0x14,0x63}, // X
        {0x07,0x08,0x70,0x08,0x07}, // Y
        {0x61,0x51,0x49,0x45,0x43}  // Z
    };

    static const uint8_t Lowercase[26][5] =
    {
        {0x20,0x54,0x54,0x54,0x78}, // a
        {0x7F,0x48,0x44,0x44,0x38}, // b
        {0x38,0x44,0x44,0x44,0x20}, // c
        {0x38,0x44,0x44,0x48,0x7F}, // d
        {0x38,0x54,0x54,0x54,0x18}, // e
        {0x08,0x7E,0x09,0x01,0x02}, // f
        {0x0C,0x52,0x52,0x52,0x3E}, // g
        {0x7F,0x08,0x04,0x04,0x78}, // h
        {0x00,0x44,0x7D,0x40,0x00}, // i
        {0x20,0x40,0x44,0x3D,0x00}, // j
        {0x7F,0x10,0x28,0x44,0x00}, // k
        {0x00,0x41,0x7F,0x40,0x00}, // l
        {0x7C,0x04,0x18,0x04,0x78}, // m
        {0x7C,0x08,0x04,0x04,0x78}, // n
        {0x38,0x44,0x44,0x44,0x38}, // o
        {0x7C,0x14,0x14,0x14,0x08}, // p
        {0x08,0x14,0x14,0x18,0x7C}, // q
        {0x7C,0x08,0x04,0x04,0x08}, // r
        {0x48,0x54,0x54,0x54,0x20}, // s
        {0x04,0x3F,0x44,0x40,0x20}, // t
        {0x3C,0x40,0x40,0x20,0x7C}, // u
        {0x1C,0x20,0x40,0x20,0x1C}, // v
        {0x3C,0x40,0x30,0x40,0x3C}, // w
        {0x44,0x28,0x10,0x28,0x44}, // x
        {0x0C,0x50,0x50,0x50,0x3C}, // y
        {0x44,0x64,0x54,0x4C,0x44}  // z
    };

    static const uint8_t Numbers[10][5] =
    {
        {0x3E,0x51,0x49,0x45,0x3E},
        {0x00,0x42,0x7F,0x40,0x00},
        {0x42,0x61,0x51,0x49,0x46},
        {0x21,0x41,0x45,0x4B,0x31},
        {0x18,0x14,0x12,0x7F,0x10},
        {0x27,0x45,0x45,0x45,0x39},
        {0x3C,0x4A,0x49,0x49,0x30},
        {0x01,0x71,0x09,0x05,0x03},
        {0x36,0x49,0x49,0x49,0x36},
        {0x06,0x49,0x49,0x29,0x1E}
    };

    static const uint8_t GlyphExclamation[5] = {0x00,0x00,0x5F,0x00,0x00};
    static const uint8_t GlyphQuote[5]       = {0x00,0x07,0x00,0x07,0x00};
    static const uint8_t GlyphApostrophe[5]  = {0x00,0x05,0x03,0x00,0x00};
    static const uint8_t GlyphOpenParen[5]   = {0x00,0x1C,0x22,0x41,0x00};
    static const uint8_t GlyphCloseParen[5]  = {0x00,0x41,0x22,0x1C,0x00};
    static const uint8_t GlyphPlus[5]        = {0x08,0x08,0x3E,0x08,0x08};
    static const uint8_t GlyphComma[5]       = {0x00,0x50,0x30,0x00,0x00};
    static const uint8_t GlyphDash[5]        = {0x08,0x08,0x08,0x08,0x08};
    static const uint8_t GlyphDot[5]         = {0x00,0x60,0x60,0x00,0x00};
    static const uint8_t GlyphSlash[5]       = {0x20,0x10,0x08,0x04,0x02};
    static const uint8_t GlyphColon[5]       = {0x00,0x36,0x36,0x00,0x00};
    static const uint8_t GlyphSemicolon[5]   = {0x00,0x56,0x36,0x00,0x00};
    static const uint8_t GlyphLessThan[5]    = {0x08,0x14,0x22,0x41,0x00};
    static const uint8_t GlyphEquals[5]      = {0x14,0x14,0x14,0x14,0x14};
    static const uint8_t GlyphGreaterThan[5] = {0x00,0x41,0x22,0x14,0x08};
    static const uint8_t GlyphQuestion[5]    = {0x02,0x01,0x51,0x09,0x06};
    static const uint8_t GlyphAt[5]          = {0x32,0x49,0x79,0x41,0x3E};
    static const uint8_t GlyphUnderscore[5]  = {0x40,0x40,0x40,0x40,0x40};
    static const uint8_t GlyphPercent[5]     = {0x63,0x13,0x08,0x64,0x63};
    static const uint8_t GlyphAmpersand[5]   = {0x36,0x49,0x55,0x22,0x50};

    const uint8_t *GetBadgeSansGlyph(char character)
    {
        if (character >= 'A' && character <= 'Z')
        {
            return Uppercase[character - 'A'];
        }

        if (character >= 'a' && character <= 'z')
        {
            return Lowercase[character - 'a'];
        }

        if (character >= '0' && character <= '9')
        {
            return Numbers[character - '0'];
        }

        switch (character)
        {
            case ' ': return GlyphSpace;
            case '!': return GlyphExclamation;
            case '"': return GlyphQuote;
            case '%': return GlyphPercent;
            case '&': return GlyphAmpersand;
            case '\'': return GlyphApostrophe;
            case '(': return GlyphOpenParen;
            case ')': return GlyphCloseParen;
            case '+': return GlyphPlus;
            case ',': return GlyphComma;
            case '-': return GlyphDash;
            case '.': return GlyphDot;
            case '/': return GlyphSlash;
            case ':': return GlyphColon;
            case ';': return GlyphSemicolon;
            case '<': return GlyphLessThan;
            case '=': return GlyphEquals;
            case '>': return GlyphGreaterThan;
            case '?': return GlyphQuestion;
            case '@': return GlyphAt;
            case '_': return GlyphUnderscore;
            default:  return GlyphUnknown;
        }
    }
}

const BitmapFont BadgeSans =
{
    5,
    7,
    1,
    GetBadgeSansGlyph
};
